# Keil uVision project MAV_TEST.uvproj, settings and files
target MAV_TEST (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: MAV_TEST +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\APP;.\BSP;.\LIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Startup/: startup_stm32f10x_md.s system_stm32f10x.c
  group SYS
    ./APP/: sysconfig.h main.c stm32f10x_it.c
  group APP
    ./APP/: Rc.h Control.c Control.h Data_Transfer.c Data_Transfer.h Imu.c Imu.h Rc.c
  group BSP
    ./BSP/: ADC.c ADC.h ANO_Tech_STM32F10x_I2C.h ANO_Tech_STM32F10x_I2C.lib BSP.c BSP.h eeprom.c eeprom.h Led.c Led.h Moto.c Moto.h MPU6050.c MPU6050.h Nrf24l01.c Nrf24l01.h Spi.c Spi.h sys.h Tim3.c Tim3.h Tim_pwm_in.c Tim_pwm_in.h Usart.c Usart.h
  group LIB
    ./LIB/: stm32f10x_usart.c core_cm3.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_conf.h
  group Read me
    ./Read me/: Read me.txt
